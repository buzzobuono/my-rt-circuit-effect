.title Lowpass filter

R 1 2 10k
CLP 2 0 79.6p

.input 1
.output 2
