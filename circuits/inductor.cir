.title Test Inductor

L1 1 2 1
Rload 2 0 1k

.input 1
.output 2
.probe V(1) V(2) I(L1)
