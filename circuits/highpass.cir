.title Highpass filter

C1 1 2 100n
R1 2 0 1.6k

.input 1
.output 2
