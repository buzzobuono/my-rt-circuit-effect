.title Bazz Fuss

V1 1 0 9

RB_TOP 1 3 820k
RB_BOT 3 0 120k

*RC 1 2 10k
*D1 2 3 DIODE Is=1e-8 N=1 Vt=0.026
**D1 2 3 D1N914 Is=100e-8 N=1 Vt=0.026 Cj0=2e-12 Vj=0.75 Mj=0.5

Q1 2 3 0 NPN Bf=400 Is=6.8e-14 Br=35.5 Vt=0.026
C2 2 4 0.1u
C1 5 3 4.7u
R2 4 0 100k
P1 3
VIN 5 0 AC 0
.INPUT 5
.OUTPUT 4
