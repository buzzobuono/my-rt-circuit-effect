.title Bazz Fuss

V1 0 1 -9
R1 1 2 100k
#D1 2 3 DIODE Is=100e-15 N=1 Vt=0.026 # IS=100E-15 RS=16 CJO=2PF TT=12NS BV=100 IBV=100E-15
D1 2 3 DIODE Is=1e-14 N=1 Vt=0.026
C2 2 4 0.1u
#Q1 2 3 0 NPN Bf=400 Is=6.8e-14 Br=35.5 Vt=0.026 # NPN IS=1.8E-14 ISE=5.0E-14 NF=.9955 NE=1.46 BF=400 BR=35.5
Q1 2 3 0 NPN Bf=200 Br=1 Is=1e-14 Vt=0.026

C1 5 3 4.7u
R2 4 0 100M

VIN 5 0 AC 0.0
.INPUT 5
.OUTPUT 4
